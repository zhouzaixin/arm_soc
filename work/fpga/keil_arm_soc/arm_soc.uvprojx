# Keil uVision project arm_soc.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: arm_soc +hex
  AfterMake: fromelf -cvf .\objects\arm_soc.axf --vhx --32x1 -o arm_soc.hex
  AfterMake: fromelf -cvf  .\objects\arm_soc.axf -o disasm.txt
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: cm0dsasm.s main.c command.c command.h sysinit.c sysinit.h system.h typesmacro.h uart.c uart.h XA1707.h
